# IAR project Test_mircode.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: nRF52810_xxAA NordicSemi nRF52810_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCIncludePath2: config; components; components\boards; components\drivers_nrf\nrf_soc_nosd; components\libraries\atomic; components\libraries\balloc; components\libraries\bsp; components\libraries\delay; components\libraries\experimental_section_vars; components\libraries\log; components\libraries\log\src; components\libraries\memobj; components\libraries\ringbuf; components\libraries\strerror; components\libraries\util; components\toolchain\cmsis\include; ; external\fprintf; integration\nrfx; modules\nrfx; modules\nrfx\hal; modules\nrfx\mdk; config
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
